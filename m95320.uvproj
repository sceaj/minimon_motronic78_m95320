# Keil uVision project m95320.uvproj, settings and files
target Target 1 (166/167)
  device: C167CS-4RM Infineon
  cpu: IRAM(0xF200-0xFDFF) XRAM(0xE000-0xE7FF) XRAM2 (0xC000-0xD7FF) IROM(0-0x7FFF) ICAN(0xE800-0xEFFF) CLOCK(25000000) MOD167
  output: m95320.bin +hex
  group Source Group 1
    ./: m95320.a66
